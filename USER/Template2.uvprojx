# Keil uVision project Template2.uvprojx, settings and files
target Template (ARM-ADS)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.0.5
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Template +hex
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c include: ..\CORE;..\STM32F10x_FWLib\inc;..\USER;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\HARDWARE\BEEP;..\HARDWARE\LED;..\HARDWARE\KEY;..\HARDWARE\EXIT;..\HARDWARE\TIMER;..\HARDWARE\OLED;..\HARDWARE\IIC;..\HARDWARE\LCD;..\HARDWARE\DHT11;..\HARDWARE\ADC;..\HARDWARE\LIGHTSENSOR;..\HARDWARE\MOTOR;..\HARDWARE\SR301;..\HARDWARE\MQ135;..\HARDWARE\RTC;..\NET\CJSON;..\NET\ESP8266;..\NET\MQTT;..\NET\onenet;..\HARDWARE\REMOTE;..\HARDWARE\sim900a;..\HARDWARE\LCD;..\HARDWARE\TOUCH;..\HARDWARE\24CXX;..\HARDWARE\IIC;..\HARDWARE\MALLOC;..\HARDWARE\USART1
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group USER
    ./: main.c stm32f10x_it.c system_stm32f10x.c
  group CORE
    ../CORE/: core_cm3.c startup_stm32f10x_hd.s
  group FWLIB
    ../STM32F10x_FWLib/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
  group HAEDWARE
    ../HARDWARE/LED/: led.c
    ../HARDWARE/BEEP/: beep.c
    ../HARDWARE/KEY/: key.c
    ../HARDWARE/EXIT/: exit.c
    ../HARDWARE/TIMER/: timer.c
    ../HARDWARE/OLED/: oled.c
    ../HARDWARE/DHT11/: dht11.c
    ../HARDWARE/ADC/: adc.c
    ../HARDWARE/LIGHTSENSOR/: lsens.c
    ../HARDWARE/MOTOR/: motor.c
    ../HARDWARE/SR301/: sr301.c
    ../HARDWARE/MQ135/: mq135.c
    ../HARDWARE/RTC/: rtc.c
    ../HARDWARE/REMOTE/: remote.c
    ../HARDWARE/sim900a/: sim900a.c
    ../HARDWARE/24CXX/: 24cxx.c
    ../HARDWARE/IIC/: myiic.c
    ../HARDWARE/LCD/: lcd.c
    ../HARDWARE/TOUCH/: touch.c
    ../HARDWARE/MALLOC/: malloc.c
    ../HARDWARE/USART1/: usart1.c
  group NET
    ../NET/CJSON/: cJSON.c
    ../NET/ESP8266/: esp8266.c
    ../NET/MQTT/: MqttKit.c
    ../NET/onenet/: onenet.c
